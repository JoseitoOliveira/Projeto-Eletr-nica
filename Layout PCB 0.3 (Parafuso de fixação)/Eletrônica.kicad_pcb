# Repository JoseitoOliveira/Projeto-Eletr-nica

## KiCad design Layout PCB 0.3 (Parafuso de fixação)/Eletrônica.kicad_pcb

Parts:
D1, D2, D3: LED; LED_D3.0mm
J1: Jack-DC; BarrelJack_Horizontal
J2, J3, J4: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
R2, R3, R4: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_Push_Dual; SW_TH_Tactile_Omron_B3F-10xx
U1: NodeMCU_v1.0; nodeMCU

Connections:
unnamed: D1.1 (K), R2.2
unnamed: D1.2 (A), U1.25 (D8)
unnamed: D2.1 (K), R3.1
unnamed: D2.2 (A), U1.15 (D0)
unnamed: D3.1 (K), R4.1
unnamed: D3.2 (A), U1.17 (D2)
unnamed: J1.1, U1.14 (VIN)
unnamed: J1.2, U1.13 (GND)
unnamed: J2.1, U1.23 (D6)
unnamed: J2.2, J3.2, J4.2, R2.1, R3.2, R4.2, SW1.2, U1.21 (GND)
unnamed: J3.1, U1.26 (RX)
unnamed: J4.1, U1.24 (D7)
unnamed: SW1.1, U1.19 (D4)

Board: 2 copper layers, 152.0 x 54.9 mm, 12 parts (0 on the bottom side), 13 nets.

## Commit log

2019-05-20 Commit inicial
